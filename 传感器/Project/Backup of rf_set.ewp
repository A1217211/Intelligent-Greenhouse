# IAR project Backup of rf_set.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\moudle; C:\Users\Newland\Desktop\06_ZigBee工程\CC2530_lib\basicrf
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group app
    ./: rf_set.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.c
  group board
    ../CC2530_lib/basicrf/: dht11.c
    ../CC2530_LIB/board/: hal_board.c
    ../CC2530_lib/board/: hal_led.c
  group common
    ../CC2530_lib/common/: hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c
    ../CC2530_LIB/common/: hal_uart.c
  group sensor_drv
    SENSOR_DRV/: BMA020.c BMA020.h dma_itg.c dma_itg.h get_adc.c get_adc.h get_swsensor.c get_swsensor.h sensor.c
    sensor_drv/: sensor.h
  group utils
    ../CC2530_lib/utils/: util.c
