# IAR project rf_set.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\moudle; C:\Users\AMENG\Desktop\06_ZigBee工程\CC2530_lib\lcd
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group app
    ./: rf_set.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.c
  group board
    ../CC2530_lib/board/: hal_board.c hal_led.c
  group common
    ../CC2530_lib/common/: hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_uart.c
  group lcd
    ../CC2530_lib/lcd/: codetab.h LCD.h
  group sensor_drv
    sensor_drv/: BMA020.c BMA020.h dma_itg.c dma_itg.h get_adc.c get_adc.h get_swsensor.c get_swsensor.h sensor.c sensor.h
  group utils
    ../CC2530_lib/utils/: util.c
